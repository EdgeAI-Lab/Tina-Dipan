# Keil uVision project Robot2.uvproj, settings and files
target RobotBig (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM_Library +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\library\STM32F10x_StdPeriph_Driver\inc;..\library\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\library\CMSIS\CM3\CoreSupport;..\inc;..\Third_Party\fatfs;..\Third_Party\ucos\src;..\Third_Party\ucos\port;..\library;..\System\delay;..\Hardware\HMC5883;..\Hardware\OLED_I2C;..\Hardware\OLED_SPI;..\Hardware\UL;..\System\USART;..\Hardware\LED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ../src/: app.c app_hooks.c stm32f10x_it.c memmanage.c bsp.c MotorCtrl.c ADC_To_Angle.c myFun.c IR.c
  group config
    ../inc/: stm32f10x_conf.h app_cfg.h bsp.h MotorCtrl.h includes.h
    ../Third_Party/ucos/src/: os_cfg.h
  group STM32F1xx_Frimware_Lib
    ../library/: STM_Library.lib bsp_sdio_sd.c
  group ucos
    ../Third_Party/ucos/src/: os_core.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../Third_Party/ucos/port/: os_cpu_a.s os_cpu_c.c
  group FatFs
    ../System/delay/: delay.c
    ../Third_Party/fatfs/: diskio.c ff.c
  group System
    ../System/USART/: usart.c
  group Hardware
    ../Hardware/UL/: UL.c
    ../Hardware/OLED_SPI/: OLED.c
    ../Hardware/LED/: LED.c
  group backup
    ../inc/: backup.txt
